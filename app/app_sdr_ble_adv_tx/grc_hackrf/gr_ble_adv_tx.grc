options:
  parameters:
    generate_options: no_gui
    id: gr_ble_adv_tx
    output_language: python
    title: gr_ble_adv_tx
  states: {}

blocks:
- name: IF
  id: variable_qtgui_range
  parameters:
    comment: |-
      中频：(0~47) <- 发送
      osmocom 建议是 15～30
      在收发模式都有影响
    label: IF
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {state: disabled}
- name: IF
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_bb_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("Begin")
    file: ../normalization_sample.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: tx_bb_gain
    freq0: tx_freq
    gain0: tx_gain
    if_gain0: IF
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: options 中设置为 GUI 模式，才能使用这个，此时需要将 main.py 对该模块的调用去掉，手动运行该块，然后单独运行 main.py.
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:55556
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', osmosdr_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
