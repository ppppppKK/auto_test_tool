options:
  parameters:
    generate_options: no_gui
    id: gr_ble_adv_tx
    output_language: python
    title: gr_ble_adv_tx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("Begin")
    file: normalization_sample.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: limesdr=000907060247100D
    bb_gain0: tx_bb_gain
    freq0: tx_freq
    gain0: tx_gain
    if_gain0: tx_if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:55556
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [zeromq_sub_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
